# IAR project Phazis_study.ewp, settings and files
configuration Phazis_study (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030CC ST STM32F030CC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F030xC
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/CMSIS/Include; ../Drivers/STM32F0xx_HAL_Driver/Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F0xx/Include; $TOOLKIT_DIR$\CMSIS\Core\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Phazis_study.hex
  ILINK.IlinkOutputFile: Phazis_study.out
  ILINK.IlinkIcfFile: stm32f030xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f030xc.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f0xx_hal_msp.c stm32f0xx_it.c
  group Application/User/Modules
    ../Modules/button/: button.c
    ../Modules/led/: led.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_exti.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
